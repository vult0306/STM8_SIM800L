# IAR project TDS.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\Google Drive\gitwork\STM8_SIM800L\TDS\STM8S_StdPeriph_Driver\inc; D:\Google Drive\gitwork\STM8_SIM800L\TDS\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TDS.srec
  ILINK.IlinkOutputFile: TDS.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: D:\Google Drive\gitwork\STM8_SIM800L\TDS\src; D:\Google Drive\gitwork\STM8_SIM800L\TDS\STM8S_StdPeriph_Driver\inc
  ASTM8.AsmIncludePath: as above
  group (top)
    ./: main.c
  group lib/inc
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_clk.h stm8s_exti.h stm8s_gpio.h stm8s_tim4.h stm8s_uart1.h
  group lib/src
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_tim4.c stm8s_uart1.c
  group src
    src/: stm8s_conf.h stm8s_it.c stm8s_it.h
